options:
  parameters:
    author: Franco Venturi
    generate_options: no_gui
    id: navtex_rx_from_raw_file
    output_language: python
    run_options: run
    title: NAVTEX decoder from RAW file (shorts)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: navtex_mondolfo.raw
    repeat: 'False'
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: short
  states: {}
- name: navtex_navtex_decoder_0
  id: navtex_navtex_decoder
  parameters:
    filename: ''
    reverse: 'False'
    samp_rate: samp_rate
    type: short
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', navtex_navtex_decoder_0, '0']

metadata:
  file_format: 1
